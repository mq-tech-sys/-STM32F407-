# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\esp8266;..\HARDWARE\as608;..\HARDWARE\beep;..\HARDWARE\key;..\HARDWARE\keyboard;..\HARDWARE\LED;..\HARDWARE\oled;..\HARDWARE\servo;..\img;..\font;..\SYSTEM\tim;..\HARDWARE\bt24-hid;..\HARDWARE\mfrc522
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/esp8266/: esp8266.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/keyboard/: keyboard.c
    ../HARDWARE/servo/: servo.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/as608/: as608.c as608_timer.c as608_uart2.c
    ../HARDWARE/bt24-hid/: ble.c
    ../HARDWARE/mfrc522/: MFRC522.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/tim/: tim.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
  group IMG
    ../img/: lock.c lock_24bit.c unlock.c unlock_24bit.c
  group FONT
    ../font/: FontDotMatrix16.c
